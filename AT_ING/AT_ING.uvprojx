# Keil uVision project AT_ING.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: AT_ING +hex
  AfterMake: fromelf.exe --bin -o AT_ING.bin ./output/AT_ING.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\src\project_common;.\src;../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x20005438 size 0x2bc8
  scatter file: .\output\AT_ING.sct
  group APP
    ./src/: main.c profile.c app.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_gpio.c peripheral_pinctrl.c peripheral_rtc.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_dma.c
  group Tools
    ../../src/Tools/: att_db_util.c
  group project_common
    ./src/project_common/: bt_cmd_data_uart_io_adp.c project_common.c project_crc.c crc.c sdk_private_flash_data.c low_power.c
  group service
    ./src/service/: throughput_service.c
  group AT
    ./src/project_common/: bt_at_cmd_parse.c
software components: CMSIS:CORE 4.3.0
