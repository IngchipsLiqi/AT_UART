# Keil uVision project transmission.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ing91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: 9168_AT +hex
  AfterMake: fromelf.exe --bin -o 9168_AT.bin ./output/9168_AT.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x200053c8 size 0x2c38
  group APP
    ./src/: main.c profile.h profile.c at_recv_cmd.c at_cmd_task.c router.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    ../../src/Tools/: trace.c att_db_util.c str_util.c ad_parser.c
  group common
    ./src/common/: preh.h flash_data.h flash_data.c
  group service
    ./src/service/: transmission_service.h transmission_service.c transmission_callback.h transmission_callback.c
  group util
    ./src/util/: utils.c utils.h circular_queue.h circular_queue.c
  group at
    ./src/at/: at_parser.c at_parser.h
software components: CMSIS:CORE 4.3.0
