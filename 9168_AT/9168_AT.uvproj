# Keil uVision project 9168_AT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ing91600 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: 9168_AT +hex
  AfterMake: fromelf.exe --bin -o 9168_AT.bin ./output/9168_AT.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../bundles/mass_conn/inc;../../bundles/mass_conn/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 33718272 size 360448
  memory RVCT9: RAM 536892808 size 10872
  group APP
    ./src/: main.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../bundles/mass_conn/ING9168xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    ../../src/Tools/: trace.c
